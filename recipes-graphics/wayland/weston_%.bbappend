RDEPENDS_${PN} += "mali-blobs"
RDEPENDS_libweston-${WESTON_MAJOR_VERSION} += "mali-blobs"
RDEPENDS_weston-examples += "mali-blobs"
